KORG_ARCHIVE_COMPRESSION = "xz"

require recipes-kernel/linux-libc-headers/linux-libc-headers.inc

SRC_URI[md5sum] = "97ca1625bb40368dc41b9a7971549071"
SRC_URI[sha256sum] = "c3927e87be4040fa8aca1b58663dc0776aaf00485604ff88a623be2f3fb07794"
