require recipes-core/meta/meta-toolchain.bb

TOOLCHAIN_HOST_TASK += "nativesdk-packagegroup-bee-toolchain-host"
TOOLCHAIN_TARGET_TASK += "packagegroup-bee-toolchain-target"
